# Keil uVision project 02_test.uvprojx, settings and files
target 02_test (6160000::V6.16::ARMCLANG)
  device: STM32WBA54KGUx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: 02_test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,BLE,USE_HAL_DRIVER,STM32WBA54xx
  c misc: -fshort-enums
  c include: ../Core/Inc;../System/Interfaces;../System/Modules;../System/Config/Log;../System/Config/LowPower;../System/Config/Debug_GPIO;../STM32_WPAN/App;../STM32_WPAN/Target;../Drivers/STM32WBAxx_HAL_Driver/Inc;../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy;../Utilities/trace/adv_trace;../Projects/Common/WPAN/Interfaces;../Projects/Common/WPAN/Modules;../Projects/Common/WPAN/Modules/BasicAES;../Projects/Common/WPAN/Modules/MemoryManager;../Projects/Common/WPAN/Modules/Nvm;../Projects/Common/WPAN/Modules/RTDebug;../Projects/Common/WPAN/Modules/SerialCmdInterpreter;../Projects/Common/WPAN/Modules/Log;../Utilities/misc;../Utilities/sequencer;../Utilities/tim_serv;../Utilities/lpm/tiny_lpm;../Middlewares/ST/STM32_WPAN;../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/config/ble_full;../Middlewares/ST/STM32_WPAN/ble/svc/Src;../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc;../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/_40nm_reg_files;../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/ot_inc;../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/inc;../Middlewares/ST/STM32_WPAN/ble;../Middlewares/ST/STM32_WPAN/ble/stack/include;../Middlewares/ST/STM32_WPAN/ble/stack/include/auto;../Middlewares/ST/STM32_WPAN/ble/svc/Inc;../Drivers/CMSIS/Include;../Core/Src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32wba54xx_flash.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wba54xx.s
  group Application/User/Core
    ../Core/Src/: main.c gp21_gnss.c imu_sensor.c ttl_uart2_router.c app_entry.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: stm32_lpm_if.c
  group Application/User/System/Modules
    ../System/Modules/: ble_timer.c
  group Application/User/System/Config/LowPower
    ../System/Config/LowPower/: user_low_power_config.c peripheral_init.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_ble.c a.c a_app.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: bleplat.c power_table.c linklayer_plat.c bpka.c ll_sys_if.c host_stack_if.c
  group Common/WPAN/Interface
    ../Projects/Common/WPAN/Interfaces/: adv_trace_usart_if.c hw_aes.c hw_otp.c hw_pka.c hw_pka_p256.c hw_rng.c timer_if.c
  group Common/WPAN/Modules
    ../Projects/Common/WPAN/Modules/: app_sys.c otp.c scm.c stm_list.c stm_queue.c
  group Common/WPAN/Modules/BasicAES
    ../Projects/Common/WPAN/Modules/BasicAES/: baes_cmac.c baes_ccm.c baes_ecb.c
  group Common/WPAN/Modules/MemoryManager
    ../Projects/Common/WPAN/Modules/MemoryManager/: advanced_memory_manager.c stm32_mm.c
  group Common/WPAN/Modules/Nvm
    ../Projects/Common/WPAN/Modules/Nvm/: nvm_emul.c
  group Common/WPAN/Modules/RTDebug
    ../Projects/Common/WPAN/Modules/RTDebug/: RTDebug.c RTDebug_dtb.c
  group Common/WPAN/Modules/SerialCmdInterpreter
    ../Projects/Common/WPAN/Modules/SerialCmdInterpreter/: serial_cmd_interpreter.c
  group Common/WPAN/Modules/Log
    ../Projects/Common/WPAN/Modules/Log/: log_module.c
  group Common/WPAN/Startup
    ../Projects/Common/WPAN/Startup/: stm32wbaxx_ResetHandler_MDK-ARM.s
  group Drivers/STM32WBAxx_HAL_Driver
    ../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_ll_utils.c stm32wbaxx_ll_exti.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_ll_tim.c stm32wbaxx_ll_gpio.c stm32wbaxx_ll_dma.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Middlewares/STM32_WPAN/LinkLayer
    ../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
    ../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: LinkLayer_BLE_Full_lib.a
  group Middlewares/STM32_WPAN/BLE
    ../Middlewares/ST/STM32_WPAN/ble/stack/lib/: stm32wba_ble_stack_full.a
    ../Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c
  group Utilities
    ../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../Utilities/sequencer/: stm32_seq.c
    ../Utilities/tim_serv/: stm32_timer.c
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
software components: CMSIS:CORE 4.3.0
